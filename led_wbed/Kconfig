## weight_wbed/Kconfig
```kconfig
config HX711_WEIGHT           
	tristate "weight hx711"
	default y 
	help                   
	  Enables weightX4 hx711
```
